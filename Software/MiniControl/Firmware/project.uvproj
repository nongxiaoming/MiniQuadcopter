# Keil uVision project project.uvproj, settings and files
target rtthread-stm32 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rtthread-stm32
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=3 OneElfS=1
  c define: STM32F10X_MD, USE_STDPERIPH_DRIVER
  c include: .;..\..\rt-thread\components\CMSIS\Include;..\..\rt-thread\components\drivers\include;..\..\rt-thread\components\init;..\..\rt-thread\include;..\..\rt-thread\libcpu\arm\common;..\..\rt-thread\libcpu\arm\cortex-m3;applications;drivers;libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --keep __rt_init*
  group Applications
    applications/: application.c startup.c
  group Drivers
    drivers/: board.c stm32f10x_it.c drv_led.c drv_usart.c drv_ssd1306.c drv_spi.c
  group STM32_StdPeriph
    libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_exti.c stm32f10x_bkp.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_dma.c misc.c
    libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ./libraries/stm32f10x_stdperiph_driver/src/: stm32f10x_pwr.c
  group Kernel
    ../../rt-thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    ../../rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.s
    ../../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
