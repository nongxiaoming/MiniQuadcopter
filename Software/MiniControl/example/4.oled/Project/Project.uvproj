# Keil uVision project Project.uvproj, settings and files
target Project For STM32F103 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Libraries\Core;..\Libraries\Device\inc;..\Startup;..\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: stm32f10x_conf.h main.c stm32f10x_it.c
  group Startup
    ../Startup/: startup_stm32f10x_md.s
  group Hardware
    ../Hardware/: delay.c led.c usart.c adc.c drv_ssd1306.c
  group Libraries/Core
    ../Libraries/Core/: core_cm3.c system_stm32f10x.c
  group Libraries/Device
    ../Libraries/Device/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
    ../../Libraries/Device/src/: stm32f10x_pwr.c
